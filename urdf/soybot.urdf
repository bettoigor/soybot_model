Commit message: :memo: Update model

File: urdf/soybot.urdf (robot description, URDF)
Before this commit: robot soybot, 11 links, 10 joints
Joints:
- joint center_camera: origin xyz=0.16 0 0.865 rpy=0 0.52 0 -> xyz=0.16 0 0.865 rpy=0 0.707 0
